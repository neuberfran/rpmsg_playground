## build/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "/home/neuberfran/nordic_connect_sw2/nrf/boards/shields/*/Kconfig.defconfig"
```
